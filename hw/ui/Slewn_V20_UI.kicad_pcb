# Repository sdwhsrw/slewn-wireless-es9-nwnw

File README.md:

# Slewn Air V20 最终版 · Wireless ES-9

手机上的 Slewn 通过 Wi-Fi 发送音符和 CV，Radxa ZERO 3W 通过 USB 控制 Expert Sleepers ES-9。硬件采用 Intellijel 1U、22 HP 面板和 Eurorack +12 V 供电。

## 下载

[最终版完整包](https://github.com/Hal-cell/slewn-wireless-es9/releases/download/v20/Slewn-Air-V20-22HP-Final.zip)包含可离线旋转的整机、Blender 文件、尺寸图和两套 PCB 工程。[板厂包](https://github.com/Hal-cell/slewn-wireless-es9/releases/download/v20/Slewn-Air-V20-22HP-Fabrication.zip)包含可编辑 KiCad 10 工程、中文 BOM、独立 Gerber 和首件贴片坐标。

| 电路板 | KiCad 工程 |
|---|---|
| MAIN 主板 | [工程](hw/main/Slewn_V20_MAIN.kicad_pro) · [PCB](hw/main/Slewn_V20_MAIN.kicad_pcb) |
| UI 面板板 | [工程](hw/ui/Slewn_V20_UI.kicad_pro) · [PCB](hw/ui/Slewn_V20_UI.kicad_pcb) |

Gerber、BOM 和贴片坐标从 KiCad 工程导出到 `out/`，不随仓库提交；发布版见上方板厂包。

## 两板如何插合

MAIN 的 J2 采用金航标成品 90° 公排针 **KH-2.54PH90-1X14P-L13.8**，UI 的 J101 采用 8.5 mm 直排母 **KH-2.54FH-1X14P-H8.5**。两件均为 1×14、2.54 mm 间距，每台各用一个。[立创公针 C2905430](https://item.szlcsc.com/3175218.html) · [立创排母 C2905420](https://item.szlcsc.com/3175194.html)

公针朝面板，排母开口朝机箱后方。将主板水平推向面板，至角码孔自然对齐后锁螺钉。14 根针的名义插深为 **5.15 mm**，两塑壳间隙 **0.85 mm**。母座弹片的有效接触范围和焊后的插拔手感须由首件验证。[插接侧剖图](old/预览/05-板间连接器侧剖.png) · [尺寸与元件摆位](old/V20-尺寸与元件摆位.pdf)

从面板背面到短侧出 USB 插头最深处为 **66.50 mm**，距 73 mm 上限余 6.50 mm。按 22.50 mm 导轨开口核对，上、下名义余量分别为 0.75 mm 和 0.60 mm。离线查看器和 Blender 总装在上方完整包中。

## 首件制板

两板均为双层 1.60 mm FR-4，35 μm 铜，ENIG 沉金。KiCad 10.0.8 检查记录显示，两板 ERC、DRC、未连和原理图差异均为零。MAIN 的 **15 个指定过孔**要求树脂填孔并双面镀铜盖孔。首件以 R20 留空、限流电源和假负载分级验证，之后接入 Radxa。[制造与上电说明](板厂与首件说明.txt) · 检查：`make check`

随附封装和 STEP 模型的来源列于各板工程中。[MAIN 库来源](hw/main/Libs/LICENSE-SOURCES.txt) · [UI 库来源](hw/ui/Libs/LICENSE-SOURCES.txt)

## KiCad design hw/ui/Slewn_V20_UI.kicad_pcb

File hw/README.md:

# hw/

One folder per KiCad project, for example:

```
hw/main/main.kicad_pro  main.kicad_sch  main.kicad_pcb
hw/main/3d/             3D models for this board (reference them as ${KIPRJMOD}/3d/...)
```

Keep everything a board needs (3D models, local libraries) inside its folder, so the folder still works
when copied out as a plain KiCad project. `make check` runs ERC and DRC on every `hw/*/*.kicad_pro`.

Parts:
C101, C102: 10nF 50V X7R; C_0805_2012Metric; MPN CL21B103KBANNNC; LCSC C1710
C103: 10nF 50V X7R; C_0805_2012Metric; MPN CL21B103KBANNNC; LCSC C1710; not fitted
C104: 100nF 50V X7R; C_0805_2012Metric; MPN CC0805KRX7R9BB104; LCSC C49678; not fitted
ENC101: PEC11R-4225F-S0024; ENC1_ENCODER; MPN PEC11R-4225F-S0024; LCSC C18198884
J101: KH-2.54FH-1X14P-H8.5; MPN KH-2.54FH-1X14P-H8.5; LCSC C2905420
J102: TB147-01-08-B / 8针 / VDD 5V / 逻辑3.3V; J2_TFT8; MPN TSW-108-07-G-S; LCSC C3335496
R101, R102, R103: 10k 1% 0805; R_0805_2012Metric; MPN 0805W8F1002T5E; LCSC C17414
R104: 10k 1% / 背光默认关闭; R_0805_2012Metric; MPN 0805W8F1002T5E; LCSC C17414; not fitted

Connections:
/UI_3V3: J101.10, R101.1, R102.1, R103.1
/UI_5V: C104.1, J101.2, J102.2
/UI_ENC_A: C101.1, ENC101.A, J101.11, R101.2
/UI_ENC_B: C102.1, ENC101.B, J101.12, R102.2
/UI_ENC_SW: C103.1, ENC101.S1, J101.13, R103.2
/UI_GND: C101.2, C102.2, C103.2, C104.2, ENC101.C, ENC101.MP, ENC101.S2, J101.1, J101.9, J101.14, J102.1, R104.2
/UI_LCD_BL: J101.8, J102.8, R104.1
/UI_LCD_CS: J101.7, J102.7
/UI_LCD_DC: J101.6, J102.6
/UI_LCD_RST: J101.5, J102.5
/UI_SPI_CLK: J101.3, J102.3
/UI_SPI_MOSI: J101.4, J102.4

Notes on the sheet:
1 J101 - to MAIN J2
1-8 display, 9-14 encoder.
Pin for pin to MAIN J2.
2 DISPLAY J102
3 ENCODER ENC101
UI / J101 接 MAIN 的 J2，按 1 至 14 脚逐一对应。
背面装直母座，开口朝箱内。
R101-R103 pull-ups, C101-C102 10 nF: the noise filter Bourns asks for on PEC11R A/B.
DIY level, no protection on this board (complexity review 2026-11-21). 0R link in the 5 V feed removed.
C103, C104, R104: DNP, spare pads only.
C103: ENC_SW is debounced in software (gpio-keys, debounce-interval).
C104: the TB147 display module carries its own LDO and capacitors.
R104: the RK3566 holds LCD_BL low from reset (internal pull-down).

Board: 2 copper layers, 84.2 x 21.0 mm, 11 parts (9 on the bottom side), 12 nets.

## KiCad design hw/main/Slewn_V20_MAIN.kicad_pcb

Parts:
C2: 22uF 25V X7R 1210; C_1210_3225Metric; MPN CL32B226KAJNNNE; LCSC C309062; not fitted
C4: 10uF 50V X7R; C_1210_3225Metric; MPN UMK325AB7106KM-P; LCSC C337485; not fitted
F1: 046802.5NRHF / 2.5 A fast; Fuse_1206_3216Metric; MPN 046802.5NRHF; LCSC C187612
J1: Radxa ZERO 3W / 向下2×20排针，间距2.54; J1_GPIO40; MPN PZ254-2-20-Z-8.5; LCSC C3012260
J2: KH-2.54PH90-1X14P-L13.8; MPN KH-2.54PH90-1X14P-L13.8; LCSC C2905430
J3: 61201021621 直立 / 降压模块旁 / 9、10脚接+12V; J3_IDC10; MPN 61201021621; LCSC C4355000
J4: PinHeader 2x14 2.54 / expansion; PinHeader_2x14_P2.54mm_Vertical; MPN PZ254-2-14-Z-8.5; LCSC C2894975
J5: PinHeader 2x03 2.54; PinHeader_2x03_P2.54mm_Vertical; MPN PZ254-2-03-Z-8.5; LCSC C2894964
Q1: AO4407C / -30V P-MOS; SOIC-8_3.9x4.9mm_P1.27mm; MPN AO4407C; LCSC C469397
R2, R3: 4.7k 1% 0805; R_0805_2012Metric; MPN 0805W8F4701T5E; LCSC C17673; not fitted
TP6: 5V; TestPoint_Pad_D1.5mm; MPN PCB pad
TP7: GND; TestPoint_Pad_D1.5mm; MPN PCB pad
U1: Waveshare DC5-36 TO DC3V3/5；设为5V; U1_Waveshare33x16; MPN DC5-36-TO-DC3V3-5

Connections:
/3V3: J1.17, J5.3, J5.4, R2.1, R3.1
/3V3_1: J1.1, J2.10
/5V: C2.1, J1.2, J1.4, J2.2, J5.1, J5.2, TP6.1 (1_1), U1.O4 (5V), U1.O5 (5V), U1.O6 (5V)
/12V_IN: C4.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), U1.I3 (VIN), U1.I4 (VIN)
/ENC_A: J1.32, J2.11
/ENC_B: J1.33, J2.12
/ENC_SW: J1.36, J2.13
/GPIO1_A4: J1.37, J4.25
/GPIO3_A1: J1.11, J4.26
/GPIO3_C4: J1.7, J4.27
/I2C4_SCL: J1.28, J4.9
/I2C4_SDA: J1.27, J4.10
/I2C5_SCL: J1.29, J4.8, R2.2
/I2C5_SDA: J1.31, J4.7, R3.2
/I2S_BCLK: J1.12, J4.5
/I2S_DIN: J1.38, J4.2
/I2S_DOUT: J1.40, J4.1
/I2S_LRCK: J1.35, J4.3
/I2S_MCLK: J1.13, J4.4
/LCD_BL: J1.18, J2.8
/LCD_CS: J1.24, J2.7
/LCD_DC: J1.16, J2.6
/LCD_RST: J1.15, J2.5
/RACK_12V: F1.1, J3.9, J3.10
/SPI_CLK: J1.23, J2.3, J4.13
/SPI_CS1: J1.22, J4.15
/SPI_MISO: J1.21, J4.14
/SPI_MOSI: J1.19, J2.4, J4.16
/UART2_RX: J1.10, J4.19
/UART2_TX: J1.8, J4.20
/UART3_RX: J1.3, J4.22
/UART3_TX: J1.5, J4.21
/VIN_FUSED: F1.2, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D)
GND: C2.2, C4.2, J1.6, J1.9, J1.14, J1.20, J1.25, J1.30, J1.34, J1.39, J2.1, J2.9, J2.14, J3.3, J3.4, J3.5, J3.6, J3.7, J3.8, J4.6, J4.11, J4.12, J4.17, J4.18, J4.23, J4.24, J4.28, J5.5, J5.6, Q1.4 (G), TP7.1 (1_1), U1.I1 (GND), U1.I2 (GND), U1.O1 (GND), U1.O2 (GND), U1.O3 (GND)

Notes on the sheet:
1 RACK INPUT - fuse, reverse-polarity P-MOS
2 5 V BUCK - Waveshare module, set to 5 V
3 RADXA ZERO 3W + UI CONNECTOR
4 EXPANSION J4 + POWER J5
SPI: same bus as the display, CS1 on J1 22.
UART2 is the boot console, 1 500 000 baud.
J5 budget: 5V max 1 A, 3V3 (Radxa) small loads.
MAIN / J2 接 UI 的 J101，按 1 至 14 脚逐一对应。
正面装原厂 90° 公排针，插向面板。
BUILD AND BRING-UP
1 Keyed ribbon cable, red stripe to -12 V at both ends.
Q1 blocks a reversed cable.
2 Check that U1 is set to 5 V.
3 Power up WITHOUT the Radxa: TP6 to TP7 reads 4.9-5.2 V.
4 Only then fit the Radxa.
5 Other modules in the rack whine? Add a ferrite bead
in series with 12V_IN before U1.
DIY level: no eFuse, TVS, input filter or service link (complexity review 2026-11-21).
C2, C4: DNP, spare pads only. The U1 module carries its own input and output capacitors.

Board: 2 copper layers, 100.0 x 54.5 mm, 14 parts (0 on the bottom side), 34 nets.

## Code that names these connections

File scripts/main_sch/layout.py (part):

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    s.nc("J3", "2")
    s.wire("J3.10", (17.78, 58.42), (17.78, 53.34), (40.64, 53.34))
    s.wire("J3.9", (40.64, 58.42), (40.64, ROW1))
    s.label("RACK_12V", (40.64, 50.8), rot=90)
    s.place("F1", 57.15, ROW1, rot=90, fields="below")
    s.wire((40.64, ROW1), "F1.1")
    # reverse-polarity P-MOS: drain from the fuse, source to the 12 V rail
    s.place("Q1", 88.9, 43.18, rot=90)
    s.wire("F1.2", "Q1.5")
    s.label("VIN_FUSED", (63.5, ROW1))
    s.wire("Q1.4", (88.9, 53.34))                # gate straight to GND: V_GS = -12 V, AO4407A takes +-25 V
    s.power("GND", (88.9, 53.34))
    s.label("12V_IN", (99.06, ROW1))
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# J5 carries the power for J4 modules (split 2026-11-22 so J4 fits the right board edge and HDMI stays free).
# J4 order (2026-11-22): groups I2S, I2C, SPI, UART, GPIO from the top; inside the groups and between them
# the pins follow their x position on J1, so the J1 -> J4 traces fan out with few crossings.
J1_NETS = {"1": "3V3_1", "2": "5V", "3": "UART3_RX", "4": "5V", "5": "UART3_TX", "7": "GPIO3_C4", "8": "UART2_TX",
           "10": "UART2_RX", "11": "GPIO3_A1", "12": "I2S_BCLK", "13": "I2S_MCLK", "15": "LCD_RST", "16": "LCD_DC",
           "17": "3V3", "18": "LCD_BL", "19": "SPI_MOSI", "21": "SPI_MISO", "22": "SPI_CS1", "23": "SPI_CLK",
           "24": "LCD_CS", "27": "I2C4_SDA", "28": "I2C4_SCL", "29": "I2C5_SCL", "31": "I2C5_SDA", "32": "ENC_A",
           "33": "ENC_B", "35": "I2S_LRCK", "36": "ENC_SW", "37": "GPIO1_A4", "38": "I2S_DIN", "40": "I2S_DOUT",
           **{p: "GND" for p in ("6", "9", "14", "20", "25", "30", "34", "39")}}
J2_NETS = {"1": "GND", "2": "5V", "3": "SPI_CLK", "4": "SPI_MOSI", "5": "LCD_RST", "6": "LCD_DC", "7": "LCD_CS",
           "8": "LCD_BL", "9": "GND", "10": "3V3_1", "11": "ENC_A", "12": "ENC_B", "13": "ENC_SW", "14": "GND"}
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           "7": "I2C5_SDA", "8": "I2C5_SCL", "9": "I2C4_SCL", "10": "I2C4_SDA", "11": "GND", "12": "GND",
           "13": "SPI_CLK", "14": "SPI_MISO", "15": "SPI_CS1", "16": "SPI_MOSI", "17": "GND", "18": "GND",
           "19": "UART2_RX", "20": "UART2_TX", "21": "UART3_TX", "22": "UART3_RX", "23": "GND", "24": "GND",
           "25": "GPIO1_A4", "26": "GPIO3_A1", "27": "GPIO3_C4", "28": "GND"}
J5_NETS = {"1": "5V", "2": "5V", "3": "3V3", "4": "3V3", "5": "GND", "6": "GND"}

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